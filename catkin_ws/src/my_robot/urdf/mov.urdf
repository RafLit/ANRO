Commit message: 6

File: catkin_ws/src/my_robot/urdf/mov.urdf (robot description, URDF)
Before this commit: robot xd, 5 links, 4 joints
Links:
- link manipulator: geometry visual box size=0.5 0.1 0.1
